# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\RTX\inc;..\..\RTX\portable;..\..\User\usb\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../User/: main.c includes.h RTX_Conf_CM.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_uart_fifo.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group RTX/Source
    ../../RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RTX/Ports
    ../../RTX/portable/: HAL_CM3.c rt_HAL_CM.h SVC_Table.s
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
  group USB/Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB/Config
    ../../User/usb/src/: hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
